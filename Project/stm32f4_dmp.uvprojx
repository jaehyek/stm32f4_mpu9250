# Keil uVision project stm32f4_dmp.uvprojx, settings and files
target stm32f4_dmp (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f4_dmp
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin -o .\stm32f4_dmp\stm32f4_dmp.bin .\stm32f4_dmp\stm32f4_dmp.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER STM32F40_41xxx ARM_MATH_CM4 __FPU_PRESENT MPU9250
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Drivers\inc;..\Application\inc;..\Libraries\eMPL;..\Matrix\inc;..\Algorithm\inc;..\Math\inc;..\miniIMU;..\miniIMU\FP;..\miniAHRS;..\Data\inc;..\Gps\inc;..\Common\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../Application/Src/: stm32f4_rcc.c stm32f4_delay.c stm32f4_mpu9250.c main.c
    ../Application/src/: stm32f4_serial.c stm32f4_ms5611.c stm32f4_ublox.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_exti.c misc.c stm32f4xx_syscfg.c stm32f4xx_spi.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_tim.c stm32f4xx_usart.c
  group CMSIS
    ../Application/Src/: system_stm32f4xx.c
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group eMPL
    ../Libraries/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group Algorithm
    ../Algorithm/src/: EKF.c UKF.c Quaternion.c PID.c INS_EKF.c SRCKF.c CKF.C
    ../Algorithm/inc/: Double.h
  group Matrix
    ../Matrix/src/: Matrix.c DoubleMatrix.c
  group DSP_Lib
    ../Libraries/CMSIS/DSP_Lib/Lib/: arm_cortexM4lf_math.lib
  group Drivers
    ../Drivers/src/: stm32f4_spi.c stm32f4_usart.c stm32f4_exti.c stm32f4_gpio.c
  group Math
    ../Math/src/: FastMath.c
  group miniIMU
    ../miniIMU/: miniIMU.c miniMatrix.c
  group FP_miniIMU
    ../miniIMU/FP/: FP_Matrix.c FP_miniIMU.c FP_Math.c
  group miniAHRS
    ../miniAHRS/: miniAHRS.c
  group Data
    ../Data/src/: Fifo.c Queue.c
  group Gps
    ../Gps/src/: Nema.c Map.c
  group Common
    ../Common/src/: Memory.c
